# IAR project DS213.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103VE ST STM32F103VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCIncludePath2: ..\APP; ..\DFU; ..\PUBLIC; STM32F103; ..\MSD; ..\..\Libraries\STM32F103\CMSIS\Inc; ..\..\Libraries\STM32F103\STM32F10x_SPD\inc; ..\..\Libraries\STM32_USB-FS-Device_Driver\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: DS213.hex
  ILINK.IlinkOutputFile: DS213.out
  ILINK.IlinkIcfFile: ..\STM32F103_APP.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group APP
    ../APP/: AppDisk.c AppStartup.s Calibrat.c Draw.c Main.c Menu.c Process.c Sys.c
  group LIB/STM32F103/CMSIS
    ../../Libraries/STM32F103/CMSIS/Src/: STM32F103_System.c
  group LIB/STM32F103/SPD
    ../../Libraries/STM32F103/STM32F10x_SPD/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group LIB/USBD
    ../../Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group MSD
    ../MSD/: USB_bot.c USB_desc.c USB_istr.c USB_prop.c USB_pwr.c USB_scsi.c
  group PUBLIC
    ../PUBLIC/: FAT12.c File.c Func.c Ident.c Ident.o Interrupt.c
