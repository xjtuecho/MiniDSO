# Keil uVision project DS201APP.uvproj, settings and files
target DS201APP (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: DS201APP +hex
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\include;..\..\..\..\FWLib\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group FWLib
    ../../../../FWLib/src/: stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_systick.c
  group Application
    ../../source/: Calculate.c Files.c Function.c HW_V1_Config.c Lcd.c main.c ASM_Funtion.s Interrupt.c
  group MDKARM
    ./: cortexm3_macro.s stm32f10x_vector.s
