# Keil uVision project DS203APP.uvproj, settings and files
target DS203APP (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: DS203SYS +hex
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\include;..\..\..\FWLib\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group FWLib
    ../../../FWLib/src/: stm32f10x_dma.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_nvic.c
  group Program
    ../source/: BIOS.s Calibrat.c Draw.c Files.c Function.c Ident.c Interrupt.c Main.c Menu.c Process.c
  group MDKARM
    ./: cortexm3_macro.s stm32f10x_vector.s
