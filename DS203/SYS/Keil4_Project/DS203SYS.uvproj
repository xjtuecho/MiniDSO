# Keil uVision project DS203SYS.uvproj, settings and files
target DS203SYS (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: DS203SYS +hex
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\include;..\..\..\FWLib\inc;..\..\..\USBLib\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Program
    ../source/: LCD.c Main.c Memory.c scsi_data.c USB_bot.c USB_desc.c USB_endp.c USB_istr.c USB_prop.c USB_scsi.c USB_pwr.c Interrupt.c Ident.c Function.c FAT12.c Ext_Flash.c Config.c BIOS.c ASM.s
  group MDK
    ./: cortexm3_macro.s stm32f10x_vector.s
  group FWLib
    ../../../FWLib/src/: stm32f10x_dma.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_spi.c
  group USBLib
    ../../../USBLib/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
